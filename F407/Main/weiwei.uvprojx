# Keil uVision project weiwei.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: weiwei +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ..\Core;..\Hardware\Include;..\System\Include;..\GUI_APP\inc;..\LVGL_GUI;..\LVGL_GUI\src;..\LVGL_GUI\driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group Hardware
    ../Hardware/Source/: pwm.c oled.c myiic.c timer.c
  group GUI_APP
    ../GUI_APP/src/: app_ui.c
  group LVGL_Core
    ../LVGL_GUI/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group LVGL_Draw
    ../LVGL_GUI/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group LVGL_Font
    ../LVGL_GUI/src/lv_font/: iconfont_16.c iconfont_18.c lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group LVGL_Hal
    ../LVGL_GUI/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_Misc
    ../LVGL_GUI/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group LVGL_Objx
    ../LVGL_GUI/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group LVGL_Themes
    ../LVGL_GUI/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group LVGL_Driver
    ../LVGL_GUI/driver/: lv_port_disp.c
  group STM32_Core
    ../Core/: startup_stm32f40_41xxx.s
  group STM32_Sys
    ../System/Source/: delay.c sys.c usart.c self_functions.c cJSON.c
  group STM32_Lib
    ../System/Source/: misc.c stm32f4xx_tim.c system_stm32f4xx.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_it.c stm32f4xx_gpio.c stm32f4xx_fsmc.c
