# Keil uVision project wei.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wei +hex
  c flags: uC99=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\GUI_APP\inc;..\HARDWARE\OLED;..\LVGL_GUI;..\LVGL_GUI\driver;..\LVGL_GUI\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group LVGL_Driver
    ../LVGL_GUI/driver/: lv_port_disp.c
  group LVGL_Core
    ../LVGL_GUI/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group LVGL_Draw
    ../LVGL_GUI/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group LVGL_Font
    ../LVGL_GUI/src/lv_font/: iconfont_16.c iconfont_18.c lv_font.c lv_font_roboto_12.c lv_font_roboto_22.c lv_font_fmt_txt.c
  group LVGL_Hal
    ../LVGL_GUI/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_Misc
    ../LVGL_GUI/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group LVGL_Objx
    ../LVGL_GUI/src/lv_objx/: lv_cont.c lv_label.c lv_page.c
  group LVGL_Themes
    ../LVGL_GUI/src/lv_themes/: lv_theme.c
  group GUI_APP
    ../GUI_APP/src/: app_ui.c
